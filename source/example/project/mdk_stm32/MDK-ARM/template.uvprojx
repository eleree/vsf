# Keil uVision project template.uvprojx, settings and files
target template (6100001::V6.10.1::.\ARMCLANG)
  device: STM32F437ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F437xx,USE_HAL_DRIVER,STM32F437xx,_MSC_VER,__STMicro__
  c misc: -fms-extensions -Wno-empty-body -Wno-microsoft-anon-tag -Wno-nonportable-include-path -Wno-tautological-constant-out-of-range-compare
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\..\..\..\vsf;..\..\..\usrapp\template;..\..\..\..\vsf\utilities\compiler\arm\CMSIS\Core\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f437xx.s
  group usrapp
    ../../../usrapp/template/: main_task_simple.c main_thread_simple.c
    ../../../usrapp/template/ooc_demo/: class_demo.c class_simple_demo.c
  group vsf/hal/arch
    ../../../../vsf/hal/arch/: vsf_arch_abstraction.c
  group vsf/hal
    ../../../../vsf/hal/: vsf_hal.c
  group vsf/kernel
    ../../../../vsf/kernel/: vsf_eda.c vsf_os.c vsf_evtq_array.c vsf_evtq_list.c vsf_kernel.h vsf_kernel_common.h vsf_kernel_cfg.h vsf_os.h vsf_kernel_bsp.c
  group vsf/kernel/task
    ../../../../vsf/kernel/task/: __vsf_task_common.h vsf_thread.c vsf_fsm.h vsf_pt.h vsf_thread.h
  group vsf/utilities/template
    ../../../../vsf/utilities/template/: template.h vsf_bitmap.c vsf_bitmap.h vsf_list.c vsf_list.h
  group vsf/kernel/utilities/3rd-party/PLOOC
    ../../../../vsf/utilities/3rd-party/PLOOC/: plooc_class_strict.h plooc_class_simple.h plooc_class.h plooc.h plooc_class_black_box.h
  group vsf/utilities
    ../../../../vsf/utilities/: communicate.h compiler.h ooc_class.h
    ../../../../vsf/utilities/language_extension/: code_region.c
    ../../../../vsf/utilities/compiler/arm/: signal.c retarget_io.c
    ../../../usrapp/stm32_demo/: user_retarget.c
  group vsf/kernel/shell/simple
    ../../../../vsf/kernel/shell/simple/: vsf_simple.h vsf_simple_bmevt.c vsf_simple_bmevt.h vsf_simple_task.c
  group vsf/hal/interface
    ../../../../vsf/hal/interface/: vsf_interface_io.h vsf_interface_pm.h vsf_interface_usart.h vsf_interface_usb.h vsf_interface_common.h
  group vsf/service/pool
    ../../../../vsf/service/pool/: vsf_pool.c vsf_pool.h
  group vsf/service
    ../../../../vsf/service/: vsf_service.c vsf_service.h
  group vsf/hal/driver
    ../../../../vsf/hal/driver/STMicro/STM32F4/: driver.c
  group Application/User
    ../Src/: main.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_hcd.c stm32f4xx_ll_usb.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group vsf/service/heap
    ../../../../vsf/service/heap/: vsf_heap.c vsf_heap.h
  group vsf/kernel/shell
    ../../../../vsf/kernel/shell/: vsf_shell.c vsf_shell.h
  group vsf/hal/arch/arm/cortex-m/systick
    ../../../../vsf/hal/arch/arm/cortex-m/SysTick/: i_io_systick.h systick.c systick_internal.c
  group vsf/hal/arch/arm/cortex-m
    ../../../../vsf/hal/arch/arm/cortex-m/: cortex_m_generic.c cortex_m_generic.h
software components: CMSIS:CORE 5.1.2
